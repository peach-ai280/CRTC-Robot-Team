# Keil uVision project STM32_PS2_Mecanum.uvprojx, settings and files
target STM32_PS2_Mecanum (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800FFFF) CLOCK(64000000) CPUTYPE("Cortex-M3") ELITTLE
  output: STM32_PS2_Mecanum +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c misc: -std=c11 -Wall -Wextra
  c include: .\src
  memory RVCT4: ROM 0x08000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\stm32f103c8.sct
  link misc: --entry=Reset_Handler --keep=startup.o(RESET)
  group Firmware
    ./src/: main.c board.c ps2_bus.c robot_control.c driver_encode.c startup.c
